inherit debian-dsc
inherit sbuild

PV = "2.10-1"

DSC_URI = "${DEBIAN_REPO}/pool/main/h/${PN}/${PN}_${PV}.dsc;md5sum=34dfe918302fda549691710425f58d1c;sha256sum=329decc4cb8172964b5e72597b6f9d5405c02ad2bf94d6a66b0a88a9425dd0b3"
